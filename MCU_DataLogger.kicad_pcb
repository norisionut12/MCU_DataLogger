# Repository norisionut12/MCU_DataLogger

File README.md:

# ⚡ MCU DataLogger – PCB Design

A compact **data logger board** built around the **ATmega328P**, the same chip that powers the Arduino Uno. It reads sensors, keeps track of the exact date and time, and saves everything to on-board memory, so it can log data on its own without a computer.

🛠️ **My part:** I recreated the schematic of an existing circuit in **KiCad 10** and designed the complete PCB for it, from component placement to routing.

## 🔍 What's on the board

| | |
|---|---|
| 🧠 **ATmega328P** | The brain of the board, running at 16 MHz |
| ⏰ **DS1337 clock** | Keeps the date and time, so every reading gets a timestamp |
| 💾 **2 × 24LC1025 memory** | 256 KB of storage that keeps the data even without power |
| 🔌 **Connectors** | Sensors (D2–D8), I²C, serial (RX/TX), programming (ICSP) and battery |

## 📐 Schematic

Redrawn in KiCad from the original circuit and organized into clear blocks: clock, MCU, memory and connectors.

<details>
<summary>Connectors sheet</summary>
<br>

</details>

## 🟩 PCB

A 2-layer board with ground fill on both sides. The crystals sit right next to their chips to keep the signals clean, and all connectors are placed on the edges.

| Component placement | Routing (red = top, blue = bottom) |
|:---:|:---:|
|  |  |

| 3D – top | 3D – bottom |
|:---:|:---:|
|  |  |

## 📂 Open the project

Open `MCU_DataLogger.kicad_pro` in **KiCad 10** or newer.

> 🚧 The board is fully designed but has not been manufactured yet.

## KiCad design MCU_DataLogger.kicad_pcb

Parts:
BT1: Battery; PinHeader_1x02_P2.54mm_Vertical
C1, C4: 0.1uF; C_0805_2012Metric
C2, C3: 22pF; C_0805_2012Metric
C5: 100nF; C_0805_2012Metric
D1, D2: LED; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.1mm
R1, R3, R6: 10k; R_0805_2012Metric
R2, R4: 4.7k; R_0805_2012Metric
R5, R7: 330; R_0805_2012Metric
U1, U3: 24LC1025; SOIC-8_5.23x5.23mm_P1.27mm
U2: DS1337S_; SOIC127P600X175-8N
U4: ATMEGA328P-AU; QFP80P900X900X120-32N; PARTREV 8271A
Y1: 32.768KHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering
Y2: 16MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering

Connections:
/D2: U4.32 (PD2); also elsewhere on the board
/D3: U4.1 (PD3); also elsewhere on the board
/D4: U4.2 (PD4); also elsewhere on the board
/D5: U4.9 (PD5); also elsewhere on the board
/D6: U4.10 (PD6); also elsewhere on the board
/D7: U4.11 (PD7); also elsewhere on the board
/D8: U4.12 (PB0); also elsewhere on the board
/MISO: U4.16 (PB4); also elsewhere on the board
/MOSI: U4.15 (PB3); also elsewhere on the board
/RESET: R6.1, U4.29 (PC6/~RESET); also elsewhere on the board
/RX: U4.30 (PD0); also elsewhere on the board
/SCK: D1.2 (A), R2.2, U1.6 (SCL), U2.6 (SCL), U3.6 (SCL), U4.17 (PB5), U4.28 (PC5); also elsewhere on the board
/SDA: R4.2, U1.5 (SDA), U2.5 (SDA), U3.5 (SDA), U4.27 (PC4); also elsewhere on the board
/TX: U4.31 (PD1); also elsewhere on the board
/Vcc: BT1.1 (+), C1.1, C5.1, D2.2 (A), R1.1, R2.1, R3.1, R4.1, R6.2, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.8 (VCC), U2.8 (VCC), U3.1 (A0), U3.3 (A2), U3.8 (VCC), U4.4 (VCC), U4.18 (AVCC); also elsewhere on the board
GND: BT1.2 (-), C1.2, C2.1, C3.1, C4.1, C5.2, R5.1, R7.2, U1.4 (GND), U1.7 (WP), U2.4 (GND), U3.2 (A1), U3.4 (GND), U3.7 (WP), U4.3 (GND), U4.5 (GND), U4.21 (GND); also elsewhere on the board
unnamed: D1.1 (K), R5.2
unnamed: D2.1 (K), R7.1
unnamed: R3.2, U2.7 (SQW/~INT)
unnamed: U2.1 (X1), Y1.2
unnamed: U2.2 (X2), Y1.1
unnamed: R1.2, U2.3 (~INTA)
unnamed: C4.2, U4.20 (AREF)
unnamed: C2.2, U4.7 (PB6), Y2.1
unnamed: C3.2, U4.8 (PB7), Y2.2

Notes on the sheet:
EEPROM
CONNECTORS
MCU
Real Time Clock
Mounting Holes

Parts:
J1: Conn_01x09_Pin; PinHeader_1x09_P2.54mm_Vertical
J2, J3: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical

Connections:
/D2: J1.1; also elsewhere on the board
/D3: J1.2; also elsewhere on the board
/D4: J1.3; also elsewhere on the board
/D5: J1.4; also elsewhere on the board
/D6: J1.5; also elsewhere on the board
/D7: J1.6; also elsewhere on the board
/D8: J1.7; also elsewhere on the board
/MISO: J4.1; also elsewhere on the board
/MOSI: J4.4; also elsewhere on the board
/RESET: J4.5; also elsewhere on the board
/RX: J3.3; also elsewhere on the board
/SCK: J2.4, J4.3; also elsewhere on the board
/SDA: J2.3; also elsewhere on the board
/TX: J3.4; also elsewhere on the board
/Vcc: J1.9, J2.2, J3.2, J4.2; also elsewhere on the board
GND: J1.8, J2.1, J3.1, J4.6; also elsewhere on the board

Board: 2 copper layers, 47.3 x 31.3 mm, 29 parts (0 on the bottom side), 25 nets.
